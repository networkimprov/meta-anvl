require recipes-connectivity/wpa-supplicant/wpa-supplicant-1.0.inc

PR = "r0"

SRC_URI[md5sum] = "3be2ebfdcced52e00eda0afe2889839d"
SRC_URI[sha256sum] = "2c115609fbb5223d51381084a5c944455a8afcda81d584173ff55ba233379e09"

LIC_FILES_CHKSUM = "file://../COPYING;md5=ab87f20cd7e8c0d0a6539b34d3791d0e \
		    file://../README;md5=5cb758942d25f6f61fd4ac388fd446fa \
		    file://wpa_supplicant.c;beginline=1;endline=11;md5=28237374d027b71cbf3ff6534857f237"
